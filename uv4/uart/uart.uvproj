# Keil uVision project uart.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: uart +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\inc\8051
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../../src/8051/: uart.c uart_isr.c
